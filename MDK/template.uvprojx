# Keil uVision project template.uvprojx, settings and files
target template_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66 --gnu
  c include: ..\source\application;..\source\bsp\inc;..\source\mcu\common;..\source\mcu\driver\inc;..\source\ecat_src\adpt;..\source\ecat_src\appl;..\source\ecat_src\common\inc;..\source\ecat_src\esc_hw;..\source\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group application
    ../source/application/: ddl_config.h main.c
  group ecat_src/adpt
    ../source/ecat_src/adpt/: ecat_appl_adpt.c ecat_appl_adpt.h
  group ecat_src/appl
    ../source/ecat_src/appl/: Demo.c Demo.h DemoObjects.h
  group ecat_src/common
    ../source/ecat_src/common/inc/: ecat_def.h
    ../source/ecat_src/common/src/: aoeappl.c bootmode.c coeappl.c diag.c ecataoe.c ecatappl.c ecatcoe.c ecateoe.c ecatfoe.c ecatslv.c ecatsoe.c emcy.c eoeappl.c foeappl.c mailbox.c objdef.c sdoserv.c
  group ecat_src/esc_hw
    ../source/ecat_src/esc_hw/: 9253hw.c 9253hw.h
  group bsp
    ../source/bsp/src/: Timer0_Drv.c Qspi_Drv.c
  group mcu/common
    ../source/mcu/common/: hc32_common.h hc32_ddl.h hc32f460.h startup_hc32f460.s system_hc32f460.c system_hc32f460.h
  group mcu/driver
    ../source/mcu/driver/src/: hc32f460_icg.c hc32f460_utility.c hc32f460_clk.c hc32f460_efm.c hc32f460_exint_nmi_swi.c hc32f460_gpio.c hc32f460_interrupts.c hc32f460_pwc.c hc32f460_qspi.c hc32f460_spi.c hc32f460_sram.c hc32f460_timer0.c hc32f460_timera.c
target template_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
